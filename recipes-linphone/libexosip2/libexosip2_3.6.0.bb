require libexosip2.inc

PR = "r0"

LIC_FILES_CHKSUM = "file://COPYING;md5=94d55d512a9ba36caa9b7df079bae19f"

inherit autotools pkgconfig

SRC_URI[md5sum] = "6fef4c110f1305048a8b307f440933d9"
SRC_URI[sha256sum] = "91da1a084c9ab663afe04b493342e075ad59ac54a1af011c7f2ba4543a923564"
